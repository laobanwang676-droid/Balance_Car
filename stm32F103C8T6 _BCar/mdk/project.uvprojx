# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,HSE_VALUE=8000000
  c include: ..\app;..\driver;..\driver\delay;..\driver\usart;..\driver\soft_i2c;..\driver\motor;..\driver\hc-sr04;..\driver\pid;..\driver\mpu6050;..\driver\encoder;..\driver\kalman;..\driver\oled;..\driver\math;..\firmware\driver\inc;..\firmware\comsis\core;..\firmware\comsis\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c app.c
  group driver
    ../driver/delay/: delay.c
    ../driver/soft_i2c/: soft_i2c.c
    ../driver/usart/: usart.c
    ../driver/mpu6050/: mpu6050.c
    ../driver/hc-sr04/: hc-sr04.c
    ../driver/motor/: motor.c
    ../driver/oled/: oled.c
    ../driver/math/: my_math.c
    ../driver/encoder/: encoder.c
    ../driver/pid/: pid.c
    ../driver/kalman/: kalman.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group firmware/comsis
    ../firmware/comsis/core/: core_cm3.c startup_stm32f10x_md.s
    ../firmware/comsis/device/: stm32f10x_it.c system_stm32f10x.c
